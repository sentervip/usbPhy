# Keil uVision project master.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: master +hex
  AfterMake: hex2bix -i -f 0xC2 -o master.iic master.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: gpif.c fw.c dscr.a51 int0.c master.c EZUSB.LIB USBJmpTb.OBJ
